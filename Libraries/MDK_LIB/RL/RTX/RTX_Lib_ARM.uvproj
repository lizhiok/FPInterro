# Keil uVision project RTX_Lib_ARM.uvproj, settings and files
target ARM_LE (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: RTX_ARM_L (library)
  AfterMake: cmd.exe /C copy ArInp.Scr ARM_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  scatter file: .\Obj\RTLRTX.sct
  group Kernel
    ./SRC/ARM/: rt_System.c rt_Task.c rt_List.c rt_Time.c rt_Event.c rt_Mailbox.c rt_Semaphore.c rt_Mutex.c rt_Timer.c rt_Robin.c rt_MemBox.c
  group Config
    ./SRC/ARM/: SWI_Table.s HAL_ARM.c HAL_ARM9F.c HAL_CR4.c
target ARM_BE (ARM-ADS)
  device: ARM7 (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI) EBIG
  output: RTX_ARM_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr ARM_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  scatter file: .\Obj\RTLRTX.sct
target ARM9F_LE (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: RTX_ARM9F_L (library)
  AfterMake: cmd.exe /C copy ArInp.Scr ARM9F_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
  scatter file: .\Obj\RTLRTX.sct
target ARM9F_BE (ARM-ADS)
  device: ARM9E-S (Big Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E) EBIG
  output: RTX_ARM9F_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr ARM9F_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c misc: --fpu=vfpv2
  scatter file: .\Obj\RTLRTX.sct
target CR4F_LE (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CR4F_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress=1786
  scatter file: .\Obj\RTLRTX.sct
target CR4F_BE (ARM-ADS)
  device: Cortex-R4F ARM
  cpu: CLOCK(160000000) CPUTYPE("Cortex-R4F") ESEL EBIG
  output: RTX_CR4_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CR4F_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c misc: --diag_suppress=1786
  scatter file: .\Obj\RTLRTX.sct
