# Keil uVision project Measure.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2129 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Measure
  c flags: Optim=4
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Main Files
    ./: Mcommand.c Getline.c Measure.c Serial.c
  group Configuration Files
    ./: RTX_Config.c Startup.s
  group Documentation
    ./: Abstract.txt
