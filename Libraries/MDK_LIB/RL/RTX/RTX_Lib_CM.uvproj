# Keil uVision project RTX_Lib_CM.uvproj, settings and files
target CM1_LE (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: RTX_CM1 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM1_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  group Kernel
    ./SRC/CM/: rt_Task.c rt_System.c rt_Event.c rt_List.c rt_Mailbox.c rt_Semaphore.c rt_Time.c rt_Timer.c rt_Mutex.c rt_Robin.c rt_MemBox.c
  group Config
    ./SRC/CM/: SVC_Table.s HAL_CM1.c HAL_CM3.c HAL_CM4.c
target CM1_BE (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1") ESEL ELITTLE
  output: RTX_CM1_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM1_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
target CM3_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM3_BE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: RTX_CM3_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM3_LE_IFX (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3_IFX (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3_LE_IFX\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM3X_LE (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: RTX_CM3X (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM3X_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG NO_EXCLUSIVE_ACCESS
target CM4F_LE (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4 (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_LE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM4F_BE (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_B (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_BE\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
target CM4F_LE_IFX (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: RTX_CM4_IFX (library)
  AfterMake: cmd.exe /C copy ArInp.Scr CM4F_LE_IFX\BuildLib.scr
  c flags: Optim=4 OneElfS=1
  c define: DBG_MSG
