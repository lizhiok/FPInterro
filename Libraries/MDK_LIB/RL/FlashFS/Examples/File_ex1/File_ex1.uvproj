# Keil uVision project File_ex1.uvproj, settings and files
target Simulator (ARM-ADS)
  device: LPC2294 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40003FFF) IROM(0-0x3FFFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: File_ex1
  c flags: Optim=4
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x40000000 size 0x4000
  group Source Files
    ./: File_ex1.c Getline.c Serial.c
  group Configuration Files
    ./: Startup.s File_Config.c Retarget.c
  group Library
    ../../../../RV31/LIB/: FS_ARM_L.lib
  group Documentation
    ./: Abstract.txt
